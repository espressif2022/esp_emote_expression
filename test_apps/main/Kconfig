## test_apps/main/Kconfig
```kconfig
menu "Expressions"
    config EXAMPLE_EXPRESSIONS_ENABLE_EMOTE
        bool "Enable Emote expression"
        default y
endmenu
```
